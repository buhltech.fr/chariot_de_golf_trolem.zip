# Autodesk Inventor part: bossage1_D�faut
Saved by Autodesk Inventor 2023.4 (Build 274418000, 418)
## iProperties
Created: 2011-01
Part Number: bossage1_D�faut
Document SubType Name: Modeling
Designer: eric
Density: 1 g/cm^3
Mass: 2.63152 g
Surface Area: 27.7817 cm^2
Volume: 2.63152 cm^3
Material: Générique
Appearance: Par défaut
Author: eric
## Design history (mm, degrees)
feature "Base1"
node "Corps solides"
node "Corps surfaciques"
node "Solide1"
