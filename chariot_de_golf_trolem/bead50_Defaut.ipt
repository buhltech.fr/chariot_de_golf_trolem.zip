# Autodesk Inventor part: bead50_D�faut
Saved by Autodesk Inventor 2023.4 (Build 274418000, 418)
## iProperties
Created: 2011-01
Part Number: bead50_D�faut
Document SubType Name: Modeling
Designer: eric
Density: 1 g/cm^3
Mass: 0.0922417 g
Surface Area: 2.44073 cm^2
Volume: 0.0922417 cm^3
Material: Générique
Appearance: Par défaut
Author: eric
## Design history (mm, degrees)
feature "Base1"
node "Corps solides"
node "Corps surfaciques"
node "Solide1"
