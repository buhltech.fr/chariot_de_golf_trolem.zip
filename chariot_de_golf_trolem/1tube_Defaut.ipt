# Autodesk Inventor part: 1tube_D�faut
Saved by Autodesk Inventor 2023.4 (Build 274418000, 418)
## iProperties
Created: 2011-01
Part Number: 1tube_D�faut
Document SubType Name: Modeling
Designer: eric
Density: 1 g/cm^3
Mass: 45.6973 g
Surface Area: 918.168 cm^2
Volume: 45.6973 cm^3
Material: Générique
Appearance: Par défaut
Author: eric
## Design history (mm, degrees)
feature "Base1"
node "Corps solides"
node "Corps surfaciques"
node "Solide1"
